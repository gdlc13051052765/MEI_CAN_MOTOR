# Keil uVision project MOTOR.uvprojx, settings and files
target MOTOR (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0xC000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: motor_con +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;..\Application\inc;..\event_manage\inc;..\Hardware\inc;..\iap_boot\inc;..\uart_debug\inc;..\Switch;..\Hardware\Ethernet\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Application/User
    ../Src/: main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group switch
    ../Switch/: HwIOConfig.h SwitchConfig.h
  group application
    ../Application/src/: application.c interface.c command.c udp_socket.c motor_control.c
  group iap_boot
    ../iap_boot/src/: st_flash.c frame_parse.c
  group event_sig
    ../event_manage/src/: mini_dispatch.c uart_debug.c crc.c def_fifo.c serial_def_fifo.c udp_fifo.c
  group hardware
    ../Hardware/src/: bsp_init.c serial.c spi_class.c led_beep.c st_crc.c bsp_GeneralTIM.c hmc80x5_api.c
  group w5500
    ../Hardware/Ethernet/W5500/: socket.c utility.c w5500.c w5500_conf.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xe.s
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_can.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_crc.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group uart_debug
    ../uart_debug/src/: debug_task.c ex_debug_func.c
software components: CMSIS:CORE 5.4.0
